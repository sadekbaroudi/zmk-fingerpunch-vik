## boards/shields/vik_display_i2c/Kconfig.shield
```kconfig
config SHIELD_VIK_DISPLAY_I2C
	def_bool $(shields_list_contains,vik_display_i2c)
```
